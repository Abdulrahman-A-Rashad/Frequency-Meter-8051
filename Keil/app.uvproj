# Keil uVision project app.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: app +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\BLL;.\HAL;..\application layers;.\Config
  group app
    ./: STARTUP.A51 Main.c
  group BLL
    ./BLL/: KeypadManager.c KeypadManager.h LCDManager.c LCDManager.h InterruptManager.c InterruptManager.h
  group HAL
    ./HAL/: Keypad.c Keypad.h LCD.c LCD.h Delay.c Delay.h Interrupt.c Interrupt.h Timer.c Timer.h
  group Config
    ./Config/: Config.h
